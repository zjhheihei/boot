# IAR project boot_hc32l176kata.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L176KATA HDSC HC32L176KATA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; lib_hc32l17x\common\; lib_hc32l17x\driver\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: boot_hc32l176kata.out
  ILINK.IlinkIcfFile: boot_hc32l17x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_cfg.h main.c
  group mde/mde_deviceCfg
    ../mde/mde_deviceCfg/: mde_deviceCfg.c mde_deviceCfg.h
  group mde/mde_deviceCfg/depend
    ../mde/mde_deviceCfg/depend/: bsp_cfg_hc32l176kata.h bsp_deviceCfg.c bsp_deviceCfg.h
  group mde/mde_storage
    ../mde/mde_storage/: mde_storage.c mde_storage.h
  group mde/mde_storage/depend
    ../mde/mde_storage/depend/: bsp_sto_hc32l176kata.h bsp_storage.c bsp_storage.h
  group pbc/lib
    ./: startup_hc32l17x.s
    lib_hc32l17x/common/: system_hc32l17x.c
  group pbc/pbc_dataConvert
    ../pbc/pbc_dataConvert/: pbc_dataConvert.c pbc_dataConvert.h
