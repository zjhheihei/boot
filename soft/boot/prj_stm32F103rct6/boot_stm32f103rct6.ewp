# IAR project boot_stm32f103rct6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ; ..\pbc\Libraries_stm32\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\pbc\Libraries_stm32\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: boot_stm32f103rct6.bin
  ILINK.IlinkOutputFile: boot_stm32f103rct6.out
  ILINK.IlinkIcfFile: boot_stm32f103rct6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group app
    ../app/: app_cfg.h main.c
  group mde/mde_deviceCfg
    ../mde/mde_deviceCfg/: mde_deviceCfg.c mde_deviceCfg.h
  group mde/mde_deviceCfg/depend
    ../mde/mde_deviceCfg/depend/: bsp_cfg_stm32f103rct6.h bsp_deviceCfg.c bsp_deviceCfg.h
  group mde/mde_storage
    ../mde/mde_storage/: mde_storage.c mde_storage.h
  group mde/mde_storage/depend
    ../mde/mde_storage/depend/: bsp_sto_stm32f103rct6.h bsp_storage.c bsp_storage.h
  group pbc/Libraries
    ../pbc/Libraries_stm32/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_rcc.c
  group pbc/Libraries/cmsis
    ../pbc/Libraries_stm32/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../pbc/Libraries_stm32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ./: system_stm32f10x.c
  group pbc/pbc_dataConver
    ../pbc/pbc_dataConvert/: pbc_dataConvert.c pbc_dataConvert.h
