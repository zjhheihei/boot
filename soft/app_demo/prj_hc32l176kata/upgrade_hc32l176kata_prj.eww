<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\upgrade_hc32l176kata.ewp</path>
  </project>
  <batchBuild/>
</workspace>


